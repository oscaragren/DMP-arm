Commit message: Changes to the simulation and pipeline

File: sim/arm/left_arm.urdf (robot description, URDF)
Before this commit: robot left_arm_final, 27 links, 26 joints
Joints:
- joint world_to_arm_base: origin xyz=0 0 0 rpy=0 0 -1.5708 -> xyz=0 0 0 rpy=0 0 1.5708
